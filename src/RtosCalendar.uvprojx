# Keil uVision project RtosCalendar.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab5
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .;src/inc/;inc/
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: eDisk.c FlashProgram.c eFile.c day_view.c day_view_controller.c month_view.c month_view_controller.c scheduler_view.c scheduler_view_controller.c year_view.c os.c osasm.s set_time_view.c set_time_view_controller.c year_view_controller.c RtosCalendar.c
    ./inc/: BSP.c Profile.c
    ./lib/date_time/: date_time_lib.c
    ./lib/calendar/: controller.c
    ./lib/event_storage/: event_storage_lib.c
  group Object
    ./: texas.o
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
